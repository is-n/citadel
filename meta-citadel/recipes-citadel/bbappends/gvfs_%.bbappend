
PACKAGECONFIG:remove = "libgphoto2"
EXTRA_OEMESON:append = " -Dlibusb=false"
