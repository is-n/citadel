
PACKAGECONFIG = "polkit systemd"
INSANE_SKIP:${PN}-src = "buildpaths"
INSANE_SKIP:${PN}-dev = "buildpaths"
