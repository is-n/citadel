PACKAGECONFIG = "\
    readline \
    systemd \
    a2dp-profiles \
    avrcp-profiles \
    hid-profiles \
    hog-profiles \
    tools \
    deprecated \
    udev \
"
