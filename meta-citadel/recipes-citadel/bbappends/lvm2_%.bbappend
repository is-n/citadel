# files/lvm.conf is customized to prevent writing to /etc
FILESEXTRAPATHS:prepend := "${THISDIR}/lvm2:"
