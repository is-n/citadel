EXTRA_OECONF_append = " --disable-raw"
