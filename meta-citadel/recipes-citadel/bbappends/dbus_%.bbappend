PACKAGECONFIG:append = " user-session"
