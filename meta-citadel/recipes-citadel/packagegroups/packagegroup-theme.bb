
inherit packagegroup

RDEPENDS:${PN} = "ttf-roboto"
